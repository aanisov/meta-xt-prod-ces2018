WESTONCORE[shell] ??= "ivi-shell.so"

WESTONIVISHELL[ivi-module] ??= "ivi-controller.so"

WESTONSECTION[WESTONIVISHELL] = "ivi-shell"

DEFAULT_SCREEN[transform]??="0"
